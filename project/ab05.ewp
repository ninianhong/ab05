# IAR project ab05.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: SOFTPACK_VERSION="2.15 (v2.15-37-ge90947b4-dirty)"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D2; CONFIG_CHIP_SAMA5D27; CONFIG_PACKAGE_289PIN; CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO4; CONFIG_HAVE_PIO4_SECURE; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_MPDDRC_DDR3; CONFIG_HAVE_MPDDRC_LPDDR3; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_DIFF_INPUT; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_PMC_AUDIO_CLOCK; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_H32MXDIV; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_SFRBU; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_XDMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SECUMOD; CONFIG_HAVE_SFC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR3_MT41K128M16; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_MODE_PERSIAN; CONFIG_HAVE_RTC_MODE_UTC; CONFIG_HAVE_RTC_TAMPER; CONFIG_HAVE_SHDWC; CONFIG_HAVE_UDPHS; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_L2CACHE; CONFIG_HAVE_UART; CONFIG_HAVE_SERIALD_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_FIFO; CUSTOM_USB; CONFIG_HAVE_I2C_BUS
  ICCARM.CCIncludePath2: ..\drivers; ..\target; ..\utils; ..\target\component; ..\target\common; ..\arch\arm; ..\arch; ..\target\pio; ..\lib\usb\include; ..\app; ..\middleware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ab05.out
  ILINK.IlinkIcfFile: E:\AB05-Test\atmel-software-package\target\sama5d2\toolchain\iar\ddram.icf
  ILINK.IlinkAdditionalLibs: E:\AB05-Test\github-atmel\usb_devices\build\Debug\Exe\usb_device.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: main.c main_descriptors.c main_usb_common.c
  group arch
    ../arch/: fault_handlers.c l1cache_cp15.c mmu_cp15.c mutex.c
  group drivers
    ../drivers/: aic5.c bus.c cache.c console.c ddram.c dma.c dma_xdmac.c flexcom.c irq.c l2cache_l2cc.c matrix.c mpddrc.c nfc.c pio4.c piobu.c pit.c pmc.c pwmc.c rstc.c rtc.c secumod.c seriald.c sfc.c sfrbu.c shdwc.c slowclock_sckc.c smc.c tc.c tcd.c twi.c twid.c uart.c usart.c usartd.c usbd_udphs.c wdt.c xdmac.c
  group iar
    ../iar/: cstartup.s
  group target
    ../target/: board_console.c board_sama5d2-xplained.c board_support.c board_timer.c chip.c chip_common.c
    ../target/common/: board_twi.c
  group utils
    ../utils/: callback.c intmath.c rand.c syscalls.c timer.c trace.c
