<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ab05.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\usb_devices\build\usb_device.ewp</path>
    </project>
    <batchBuild />
</workspace>
